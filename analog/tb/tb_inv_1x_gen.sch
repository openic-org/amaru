** sch_path: analog/tb/tb_inv_1x_gen.sch
**.subckt tb_inv_1x_gen
V1 VDD GND 1.2
C1 Z VSS 10f m=1
V2 VSS GND 0
V3 A VSS dc 0 pulse 0 1.2 2n 100p 100p 2n 4n
x1 VDD A Z VSS test_pcell.py_@wn_um_@wp_um
**** begin user architecture code


.param temp=27
.tran 50p 20n
.save all




.lib cornerMOSlv.lib mos_tt


**** end user architecture code
**.ends
.GLOBAL GND
.end
