** sch_path: analog/tb/tb_ldo_gen.sch
**.subckt tb_ldo_gen
V1 VDD GND dc 1.6 ac 1
V2 VSS GND 0
V3 VREF VSS 0.6
R3 VLDO VSS 26.16k m=1
x1 VREF VLDO net1 VSS net1 VDD ldo01.py_@Iload_@Vldo_@Vrect_@Vref
**** begin user architecture code


.param temp=27
.options savecurrents
.op
.save all  @n.x1.xm1.nsg13_lv_pmos[ids]  @n.x1.xm1.nsg13_lv_pmos[gm]  @n.x1.xm1.nsg13_lv_pmos[gds]

.control
  ac dec 160 10 1g
  set filetype=ascii
  set units=degress
  let PSRR = 1/VLDO
  write tb_ldo_g1.raw vdb(PSRR) vp(PSRR)
  set appendwrite
.endc




.lib cornerMOSlv.lib mos_tt


**** end user architecture code
**.ends
.GLOBAL GND
.end
