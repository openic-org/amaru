** sch_path: analog/tb/tb_rect_gen_2.sch
**.subckt tb_rect_gen_2
V1 net3 VSS dc 0 sin(0 500m 403Meg)
V2 VSS GND 0
x1 VA VSS VO1 VB rect_unit.py_@Ls_@Rs_@f_sr_@q_coil_@f_op_@Vrect_@Vrfpeak_@Isys
C6 VOUT VSS 0.1n m=1
R1 net1 VSS 160k m=1
V3 VOUT net1 0
L1 net2 VB 47n m=1
R2 VA net2 0.419 m=1
C4 VA VB 0.15412p m=1
C5 VA VB 3.1643p m=1
L3 net3 VSS 47n m=1
K1 L3 L1 1
x2 VA VO1 VO2 VB rect_unit.py_@Ls_@Rs_@f_sr_@q_coil_@f_op_@Vrect_@Vrfpeak_@Isys
x3 VA VO2 VOUT VB rect_unit.py_@Ls_@Rs_@f_sr_@q_coil_@f_op_@Vrect_@Vrfpeak_@Isys
**** begin user architecture code


.param temp=27
.tran 0.2n 50u
.save VA VB VO1 VO2 VOUT I(V1) I(V3)  @n.x1.xm1.nsg13_lv_nmos[ids] @n.x1.xm2.nsg13_lv_nmos[ids]  @n.x1.xm3.nsg13_lv_pmos[ids] @n.x1.xm4.nsg13_lv_pmos[ids]  @n.x3.xm1.nsg13_lv_nmos[ids] @n.x3.xm2.nsg13_lv_nmos[ids]  @n.x3.xm3.nsg13_lv_pmos[ids] @n.x3.xm4.nsg13_lv_pmos[ids]

.control
  run
  let id1m1 = @n.x1.xm1.nsg13_lv_nmos[ids]
  let id1m2 = @n.x1.xm2.nsg13_lv_nmos[ids]
  let id1m3 = @n.x1.xm3.nsg13_lv_pmos[ids]
  let id1m4 = @n.x1.xm4.nsg13_lv_pmos[ids]
  let id3m1 = @n.x3.xm1.nsg13_lv_nmos[ids]
  let id3m2 = @n.x3.xm2.nsg13_lv_nmos[ids]
  let id3m3 = @n.x3.xm3.nsg13_lv_pmos[ids]
  let id3m4 = @n.x3.xm4.nsg13_lv_pmos[ids]
  set filetype=ascii
  write tb_rect_g2.raw v(VA) v(VB) v(VO1) v(VO2) v(VOUT) I(V1) I(V3) id1m1 id1m2 id1m3 id1m4 id3m1
+ id3m2 id3m3 id3m4
.endc




.lib cornerMOSlv.lib mos_tt


**** end user architecture code
**.ends
.GLOBAL GND
.end
