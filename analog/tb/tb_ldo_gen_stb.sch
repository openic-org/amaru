** sch_path: analog/tb/tb_ldo_gen_stb.sch
**.subckt tb_ldo_gen_stb
V1 VDD GND 1.6
V2 VSS GND 0
V3 VREF VSS 0.6
R3 VLDO VSS 26.16k m=1
X999 net2 net1 loopgainprobe
x1 VREF VLDO net2 VSS net1 VDD ldo01.py_@Iload_@Vldo_@Vrect_@Vref
**** begin user architecture code


.param temp=27
.options savecurrents
.ac dec 80 1 10g
.save all v(X999.x) i(v.X999.Vi)  @n.x1.xm1.nsg13_lv_pmos[ids]  @n.x1.xm1.nsg13_lv_pmos[gm]  @n.x1.xm1.nsg13_lv_pmos[gds]

.control
  run
  alter i.X999.Ii acmag=1
  alter v.X999.Vi acmag=0
  run

  let A=ac2.i(v.X999.Vi)
  let B=ac1.i(v.X999.Vi)
  let C=ac2.v(X999.x)
  let D=ac1.v(X999.x)
  let Ttian=(2*(B*C-A*D)+D+A)/(2*(B*C-A*D)+A+D-1)

  set filetype=ascii
  write tb_ldo_g1_stb.raw db(Ttian) 180*cph(Ttian)/pi

  set appendwrite
  op
  set filetype=ascii
  write tb_ldo_gen_stb1.raw
.endc




.lib cornerMOSlv.lib mos_tt


**** end user architecture code
**.ends
.GLOBAL GND
.end
